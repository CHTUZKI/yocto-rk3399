# U-Boot configuration fragment for RK3399
# This file enables filesystem support for U-Boot
