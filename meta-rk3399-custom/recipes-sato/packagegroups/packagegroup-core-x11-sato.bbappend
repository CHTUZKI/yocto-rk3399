# Override NETWORK_MANAGER to disable connman-gnome
# We use networkmanager instead, so we don't need connman-gnome
NETWORK_MANAGER = ""

