PACKAGECONFIG:append = " glx"
